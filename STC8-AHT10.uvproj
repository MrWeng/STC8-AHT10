# Keil uVision project STC8-AHT10.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: STC8-AHT10 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\AHT10;.\Delay;.\UART;.\IIC
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./AHT10/: AHT10.c
    ./Delay/: Delay.c
    ./UART/: Uart.c
    ./IIC/: IIC.c
